# Keil uVision project BLE_Throughput_EXT.uvprojx, settings and files
target Server (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-2 STMicroelectronics
  pack: Keil.STBlueNRG-2_DFP.1.0.1
  cpu: IROM(0x10040000,0x40000) IRAM(0x20000000,0x6000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: BLE_Throughput_EXT_Server +hex
  AfterMake: fromelf.exe --bin Server\Objects\BLE_Throughput_EXT_Server.axf --output Server\Objects\BLE_Throughput_EXT_Server.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ SMPS_INDUCTOR=SMPS_INDUCTOR_10uH SERVER=1 UART_BAUDRATE=921600 BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION BLUENRG2_DEVICE HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ USER_BUTTON=BUTTON_1
  c misc: --wchar32
  c include: ..\..\inc;..\..\..\..\..\Library\hal\inc;..\..\..\..\..\Library\BlueNRG1_Periph_Driver\inc;..\..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include;..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\Bluetooth_LE\inc;..\..\..\..\..\Library\BLE_Application\layers_inc;..\..\..\..\..\Library\BLE_Application\Utils\inc;..\..\..\..\..\Library\BLE_Application\OTA\inc;..\..\..\..\..\Library\SDK_Eval_BlueNRG1\inc
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: BlueNRG2.sct
  group HAL
    ../../../../../Library/hal/src/: clock.c context_switch.s gp_timer.c miscutil.c osal.c
  group Library
    ../../../../../Library/BlueNRG1_Periph_Driver/src/: BlueNRG1_adc.c BlueNRG1_dma.c BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_i2c.c BlueNRG1_mft.c BlueNRG1_pka.c BlueNRG1_rtc.c BlueNRG1_spi.c BlueNRG1_sysCtrl.c BlueNRG1_uart.c BlueNRG1_wdg.c misc.c
  group Platform_Layers
    ../../../../../Library/SDK_Eval_BlueNRG1/src/: SDK_EVAL_Button.c SDK_EVAL_Com.c SDK_EVAL_Config.c SDK_EVAL_Led.c
  group Stack
    ../../../../../Library/Bluetooth_LE/library/: libbluenrg1_stack.a
    ../../../../../Library/cryptolib/: libcrypto.a
    ../../../../../Library/Bluetooth_LE/src/: stack_user_cfg.c
  group Startup
    ../../../../../Library/CMSIS/Device/ST/BlueNRG1/Source/: system_bluenrg1.c
  group User
    ../../src/: BLE_Throughput_EXT_main.c BlueNRG1_it.c gatt_db.c throughput.c
target Client (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: BlueNRG-2 STMicroelectronics
  pack: Keil.STBlueNRG-2_DFP.1.0.1
  cpu: as above
  output: BLE_Throughput_EXT_Client +hex
  AfterMake: fromelf.exe --bin Client\Objects\BLE_Throughput_EXT_Client.axf --output Client\Objects\BLE_Throughput_EXT_Client.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ SMPS_INDUCTOR=SMPS_INDUCTOR_10uH CLIENT=1 UART_BAUDRATE=921600 BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION BLUENRG2_DEVICE HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ USER_BUTTON=BUTTON_1
  c misc: --wchar32
  c include: as above
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: BlueNRG2.sct
